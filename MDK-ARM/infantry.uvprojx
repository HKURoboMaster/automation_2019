# Keil uVision project infantry.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry
  AfterMake: fromelf.exe  --bin -o ./bin/infantry.bin ../build/@p.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4
  c include: ..\bsp\cubemx\Core\Inc;..\bsp\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc;..\bsp\cubemx\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\bsp\cubemx\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\bsp\cubemx\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\bsp\cubemx\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\bsp\cubemx\Drivers\CMSIS\Include;..\bsp\cubemx\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\bsp\cubemx\Middlewares\Third_Party\FreeRTOS\Source\include;..\bsp\cubemx\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\bsp\cubemx\USB_DEVICE\App;..\bsp\cubemx\USB_DEVICE\Target;..\bsp\boards;..\components\algorithm;..\components\devices;..\components\modules;..\components\object;..\components\support;..\application;..\components\controller;..\test;..\utilities;..\utilities\ulog;..\utilities\finsh;..\application\protocol;..\config;..\engineer\Upper;..\engineer\Tasks;..\engineer\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../application/: init.c communicate.c chassis_task.c timer_task.c infantry_cmd.c offline_check.c referee_system.c
  group config
    ../config/: ulog_config.h
  group boards
    ../bsp/boards/: board.c drv_can.c drv_imu.c drv_flash.c drv_dr16.c drv_io.c drv_uart.c
  group object
    ../components/object/: object.c sys.h
  group device
    ../components/devices/: device.c motor.c dbus.c detect.c
  group controller
    ../components/controller/: controller.c pid_controller.c
  group modules
    ../components/modules/: chassis.c
  group algorithm
    ../components/algorithm/: mecanum.c madgwick_ahrs.c mahony_ahrs.c pid.c ramp.c
  group utilities
    ../utilities/: period.c soft_timer.c
    ../utilities/ulog/: ulog.c ulog_console.c
  group test
    ../test/: test.c test_module.c log_test.c
  group protocol
    ../application/protocol/: protocol.c protocol_common.c protocol_transmit.c protocol_interface.c
  group support
    ../components/support/: fifo.c mem_mang4.c mem_mang.h mf_crc.c linux_list.h macro_mutex.h
  group freertos
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../application/: param.c
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../bsp/cubemx/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group cubemx
    ../bsp/cubemx/Core/Src/: can.c dma.c freertos.c gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c system_stm32f4xx.c tim.c usart.c i2c.c adc.c
    ../bsp/cubemx/USB_DEVICE/App/: usbd_cdc_if.c
  group usb_device
    ../bsp/cubemx/USB_DEVICE/App/: usb_device.c usbd_desc.c
    ../bsp/cubemx/USB_DEVICE/Target/: usbd_conf.c
    ../bsp/cubemx/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../bsp/cubemx/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group stm32f4xx_hal
    ../bsp/cubemx/Core/Src/: startup_stm32f427xx.s
    ../bsp/cubemx/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group engineer/lib
    ../engineer/Lib/: servos.c servos.h engg_gpio.c engg_gpio.h pneumatic.c pneumatic.h engg_adc.c engg_adc.h
  group engineer/tasks
    ../engineer/Tasks/: dualmotor.c dualmotor.h engineer.c engineer.h moonrover.c moonrover.h grab.c grab.h locomotion.c locomotion.h
    ../engineer/Error/: error_handling.c error_handling.h
  group engineer/upper
    ../engineer/Upper/: upper.c upper.h sub_engineer.c sub_engineer.h
